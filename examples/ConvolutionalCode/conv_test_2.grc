<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>qt_qss_theme</key><value>/home/mbkitine/Pictures/Selection_017.png</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>decoder</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>1293</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79,109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>encoder</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>framebits</key><value>1293</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79,109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync1</value></param>
<param><key>value</key><value>"00011010110011111111110000011101"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync2</value></param>
<param><key>value</key><value>"0000001101000111011101101100011100100111001010001001010110110000"</value></param>
</block>
<block>
<key>baseband_debug_ccsds_deframer</key>
<param><key>id</key><value>baseband_debug_ccsds_deframer_0</value></param>
<param><key>sync</key><value>1</value></param>
<param><key>frame_length</key><value>113</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_1</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/mbkitine/Dropbox/Lulea/GRC/DeepSpace/gr-ccsds/examples/ConvolutionalCode/conv.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>filter</key><value></value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_1</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>ccsds_cc_depuncture</key>
<param><key>id</key><value>ccsds_cc_depuncture_0</value></param>
<param><key>delay</key><value>0</value></param>
<param><key>puncpat</key><value>13</value></param>
<param><key>puncsize</key><value>4</value></param>
<param><key>symbol</key><value>0</value></param>
</block>
<block>
<key>ccsds_convDecoder</key>
<param><key>id</key><value>ccsds_convDecoder_0</value></param>
<param><key>frame_size</key><value>1273</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>pad</key><value>0</value></param>
<param><key>polys</key><value>[79,-109]</value></param>
</block>
<block>
<key>ccsds_convEncoder</key>
<param><key>id</key><value>ccsds_convEncoder_0</value></param>
<param><key>invert</key><value>1</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_bb</key>
<param><key>id</key><value>digital_correlate_access_code_tag_bb_0</value></param>
<param><key>access_code</key><value>sync1</value></param>
<param><key>tagname</key><value>"sync"</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_0</value></param>
<param><key>map</key><value>[-1,1]</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0</value></param>
<param><key>decoder_list</key><value>decoder_variable</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>threadtype</key><value>capillary</value></param>
</block>
<block>
<key>fec_puncture_xx</key>
<param><key>id</key><value>fec_puncture_xx_0</value></param>
<param><key>delay</key><value>0</value></param>
<param><key>puncpat</key><value>13</value></param>
<param><key>puncsize</key><value>4</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>label1</key><value>"NRZ"</value></param>
<param><key>label2</key><value>"Biphase"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>label1</key><value>"Biphase-L"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>baseband_debug_ccsds_deframer_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_1</source_block_id><sink_block_id>ccsds_cc_depuncture_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_1</source_block_id><sink_block_id>ccsds_convEncoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_cc_depuncture_0</source_block_id><sink_block_id>ccsds_convDecoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_convDecoder_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_convEncoder_0</source_block_id><sink_block_id>fec_puncture_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0</source_block_id><sink_block_id>baseband_debug_ccsds_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_0</source_block_id><sink_block_id>blocks_char_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_puncture_xx_0</source_block_id><sink_block_id>digital_map_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
