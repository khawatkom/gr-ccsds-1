<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SNR</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cfo</value></param>
<param><key>value</key><value>0.25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_size</value></param>
<param><key>value</key><value>vcdu_size + 10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>intDepth</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>linecode</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ntaps</value></param>
<param><key>value</key><value>40*sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>parity</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>polyphase_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(sps*nfilts, nfilts, 1.0/float(sps), 0.35, 20*sps*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>reset</value></param>
<param><key>value</key><value>frame_size</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rs</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>symbol_rate*sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>scramble</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol</value></param>
<param><key>value</key><value>[-1,1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>500e3</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>taps</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>gain</key><value>sps</value></param>
<param><key>ntaps</key><value>ntaps</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>symbol_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>to</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>value</value></param>
<param><key>value</key><value>[0,1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vcdu_size</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/mbkitine/Dropbox/Lulea/GRC/DeepSpace/binfiles/qbee.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>length_tag</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"vcdu_len"</value></param>
<param><key>packet_len</key><value>vcdu_size</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag_key</key><value>"rs"</value></param>
<param><key>packet_len</key><value>frame_size + 32</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>ccsds_createCADU</key>
<param><key>id</key><value>ccsds_createCADU_0</value></param>
<param><key>frame_length</key><value>frame_size + intDepth*parity</value></param>
<param><key>len_tag_key</key><value>rshh</value></param>
<param><key>scramble</key><value>scramble</value></param>
<param><key>sync</key><value>1ACFFC1D</value></param>
</block>
<block>
<key>ccsds_decodeRS</key>
<param><key>id</key><value>ccsds_decodeRS_0</value></param>
<param><key>fert</key><value>0</value></param>
<param><key>intDepth</key><value>intDepth</value></param>
<param><key>pass_all</key><value>0</value></param>
<param><key>code</key><value>rs</value></param>
</block>
<block>
<key>ccsds_encodeRS</key>
<param><key>id</key><value>ccsds_encodeRS_0</value></param>
<param><key>cbSize</key><value>frame_size</value></param>
<param><key>intDepth</key><value>intDepth</value></param>
<param><key>len_tag_key</key><value>cadu_len</value></param>
<param><key>out_tag_key</key><value>rshh</value></param>
<param><key>code</key><value>rs</value></param>
</block>
<block>
<key>ccsds_genCADU</key>
<param><key>id</key><value>ccsds_genCADU_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>frameLength</key><value>frame_size</value></param>
<param><key>intDepth</key><value>intDepth</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>rs</key><value>rs</value></param>
<param><key>scramble</key><value>scramble</value></param>
<param><key>sync</key><value>1ACFFC1D</value></param>
</block>
<block>
<key>ccsds_processCADU</key>
<param><key>id</key><value>ccsds_processCADU_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>frameLength</key><value>frame_size</value></param>
<param><key>intDepth</key><value>intDepth</value></param>
<param><key>rs</key><value>rs</value></param>
<param><key>scramble</key><value>scramble</value></param>
<param><key>tagName</key><value>"sync"</value></param>
</block>
<block>
<key>ccsds_recoverCADU</key>
<param><key>id</key><value>ccsds_recoverCADU_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>frame_length</key><value>frame_size + 32</value></param>
<param><key>scramble</key><value>scramble</value></param>
<param><key>tag_name</key><value>"sync"</value></param>
</block>
<block>
<key>ccsds_recoverCADU</key>
<param><key>id</key><value>ccsds_recoverCADU_1</value></param>
<param><key>frame_length</key><value>frame_size  + intDepth*parity</value></param>
<param><key>scramble</key><value>scramble</value></param>
<param><key>tag_name</key><value>sync</value></param>
</block>
<block>
<key>ccsds_synchronizeCADU</key>
<param><key>id</key><value>ccsds_synchronizeCADU_0</value></param>
<param><key>syncWord</key><value>1ACFFC1D</value></param>
<param><key>tagName</key><value>"sync"</value></param>
<param><key>tolerance</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math, numpy</value></param>
</block>
<block>
<key>mapper_prbs_sink_b</key>
<param><key>id</key><value>mapper_prbs_sink_b_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>which_mode</key><value>"PRBS31"</value></param>
<param><key>reset_len</key><value>reset</value></param>
</block>
<block>
<key>mapper_prbs_source_b</key>
<param><key>id</key><value>mapper_prbs_source_b_0</value></param>
<param><key>which_mode</key><value>"PRBS31"</value></param>
<param><key>reset_len</key><value>reset</value></param>
</block>
<block>
<key>tdd_ferMsgCount</key>
<param><key>id</key><value>tdd_ferMsgCount_0</value></param>
<param><key>verbose</key><value>1</value></param>
</block>
<block>
<key>tdd_ferMsgGen</key>
<param><key>id</key><value>tdd_ferMsgGen_0</value></param>
<param><key>frame_size</key><value>vcdu_size</value></param>
<param><key>len_tag_key</key><value>vcdu_len</value></param>
<param><key>out_tag_key</key><value>cadu_len</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>ccsds_genCADU_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>tdd_ferMsgGen_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>ccsds_createCADU_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>ccsds_synchronizeCADU_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_0</source_block_id><sink_block_id>mapper_prbs_sink_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_createCADU_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_decodeRS_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>vcdu</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ccsds_decodeRS_0</source_block_id><sink_block_id>tdd_ferMsgCount_0</sink_block_id><source_key>vcdu</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ccsds_encodeRS_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_encodeRS_0</source_block_id><sink_block_id>ccsds_createCADU_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_genCADU_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_processCADU_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ccsds_recoverCADU_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>cadu</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ccsds_recoverCADU_1</source_block_id><sink_block_id>ccsds_decodeRS_0</sink_block_id><source_key>cadu</source_key><sink_key>cadu</sink_key></connection>
<connection><source_block_id>ccsds_synchronizeCADU_0</source_block_id><sink_block_id>ccsds_processCADU_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_synchronizeCADU_0</source_block_id><sink_block_id>ccsds_recoverCADU_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_synchronizeCADU_0</source_block_id><sink_block_id>ccsds_recoverCADU_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_prbs_source_b_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tdd_ferMsgCount_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>store</sink_key></connection>
<connection><source_block_id>tdd_ferMsgGen_0</source_block_id><sink_block_id>ccsds_encodeRS_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
