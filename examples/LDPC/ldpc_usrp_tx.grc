<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ldpc_fert</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EbNo</value></param>
<param><key>value</key><value>4.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>K</value></param>
<param><key>value</key><value>7136</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>8160</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rc</value></param>
<param><key>value</key><value>K*1.0/N*1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rm</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cadu_size</value></param>
<param><key>value</key><value>N/8</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>const</value></param>
<param><key>type</key><value>bpsk</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>intDepth</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>linecode</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ntaps</value></param>
<param><key>value</key><value>10*sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>parity</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>polyphase_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(sps*nfilts, nfilts, 1.0/float(sps), 0.35, 20*sps*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rs</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>symbol_rate*sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>scramble</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sigma</value></param>
<param><key>value</key><value>math.sqrt(1.0/(2*math.pow(10.0,EbNo/10.0)))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol</value></param>
<param><key>value</key><value>[-1,1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>5000e3</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>taps</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>gain</key><value>sps</value></param>
<param><key>ntaps</key><value>ntaps</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>symbol_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>value</value></param>
<param><key>value</key><value>[0,1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vcdu_size</value></param>
<param><key>value</key><value>7136</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>voltage_0</value></param>
<param><key>value</key><value>(math.sqrt(2)/math.sqrt(2*Rm*Rc*math.pow(10.0,EbNo/10.0)))/math.sqrt(sps)</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>(math.sqrt(2)/math.sqrt(2*Rm*Rc*math.pow(10.0,EbNo/10.0)))/math.sqrt(sps)</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>7056</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>length_tag</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>pkt_len</value></param>
<param><key>packet_len</key><value>7056</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0</value></param>
<param><key>len_tag_key</key><value>vcdu_len</value></param>
<param><key>packet_len</key><value>7136</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>display</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_1</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_2</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vector</key><value>[1] + [0]*7153</value></param>
</block>
<block>
<key>bpsk_bpskIQMap</key>
<param><key>id</key><value>bpsk_bpskIQMap_0</value></param>
</block>
<block>
<key>bpsk_bpskPulseshapeRRC</key>
<param><key>id</key><value>bpsk_bpskPulseshapeRRC_0</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>rollof</key><value>0.35</value></param>
<param><key>nTaps</key><value>ntaps</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>symbol_rate</key><value>symbol_rate</value></param>
</block>
<block>
<key>bpsk_bpskSoftDecision</key>
<param><key>id</key><value>bpsk_bpskSoftDecision_0</value></param>
<param><key>qBits</key><value>10</value></param>
<param><key>qThreshold</key><value>2</value></param>
<param><key>qType</key><value>1</value></param>
</block>
<block>
<key>ccsds_createCADU</key>
<param><key>id</key><value>ccsds_createCADU_0</value></param>
<param><key>frame_length</key><value>cadu_size</value></param>
<param><key>len_tag_key</key><value>cadu_len</value></param>
<param><key>scramble</key><value>1</value></param>
<param><key>sync</key><value>1ACFFC1D</value></param>
</block>
<block>
<key>ccsds_decodeLDPC</key>
<param><key>id</key><value>ccsds_decodeLDPC_0</value></param>
<param><key>alist_file</key><value>"/home/mbkitine/Dropbox/Lulea/GRC/DeepSpace/gr-ccsds/lib/fec/ldpc/alist/AR4JA_r12_k1024n.a"</value></param>
<param><key>code_type</key><value>1</value></param>
<param><key>iterations</key><value>20</value></param>
<param><key>pack</key><value>1</value></param>
<param><key>sigma</key><value>sigma</value></param>
<param><key>update_sigma</key><value>1</value></param>
</block>
<block>
<key>ccsds_encodeLDPC</key>
<param><key>id</key><value>ccsds_encodeLDPC_0</value></param>
<param><key>circulant_file</key><value>"empy.txt"</value></param>
<param><key>code_type</key><value>1</value></param>
<param><key>len_tag_key</key><value>"vcdu_len"</value></param>
<param><key>out_tag_key</key><value>cadu_len</value></param>
<param><key>verbose</key><value>0</value></param>
</block>
<block>
<key>ccsds_recoverCADUSoft</key>
<param><key>id</key><value>ccsds_recoverCADUSoft_0</value></param>
<param><key>frame_length</key><value>N</value></param>
<param><key>scramble</key><value>1</value></param>
<param><key>tag_name</key><value>sync</value></param>
</block>
<block>
<key>ccsds_synchronizeCADUSoft</key>
<param><key>id</key><value>ccsds_synchronizeCADUSoft_0</value></param>
<param><key>frame_size</key><value>N + 32</value></param>
<param><key>fec</key><value>0</value></param>
<param><key>invCC</key><value>0</value></param>
<param><key>lts</key><value>7</value></param>
<param><key>stl</key><value>1</value></param>
<param><key>slip</key><value>0</value></param>
<param><key>sync</key><value>1ACFFC1D</value></param>
<param><key>tag_name</key><value>sync</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>sps</value></param>
<param><key>taps</key><value>taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math, numpy</value></param>
</block>
<block>
<key>mapper_prbs_sink_b</key>
<param><key>id</key><value>mapper_prbs_sink_b_0</value></param>
<param><key>which_mode</key><value>"PRBS31"</value></param>
<param><key>reset_len</key><value>7056</value></param>
</block>
<block>
<key>mapper_prbs_source_b</key>
<param><key>id</key><value>mapper_prbs_source_b_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>which_mode</key><value>"PRBS31"</value></param>
<param><key>reset_len</key><value>7056</value></param>
</block>
<block>
<key>tdd_ferMsgCount</key>
<param><key>id</key><value>tdd_ferMsgCount_0</value></param>
<param><key>crc</key><value>1</value></param>
<param><key>framesync</key><value>0</value></param>
<param><key>verbose</key><value>1</value></param>
</block>
<block>
<key>tdd_ferMsgGen</key>
<param><key>id</key><value>tdd_ferMsgGen_0</value></param>
<param><key>frame_size</key><value>882</value></param>
<param><key>len_tag_key</key><value>pkt_len</value></param>
<param><key>out_tag_key</key><value></value></param>
</block>
<block>
<key>tdd_nullMsgSink</key>
<param><key>id</key><value>tdd_nullMsgSink_0</value></param>
<param><key>meta</key><value>1</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>tdd_ferMsgGen_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>ccsds_encodeLDPC_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>bpsk_bpskPulseshapeRRC_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_1</source_block_id><sink_block_id>mapper_prbs_sink_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_2</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bpsk_bpskIQMap_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bpsk_bpskPulseshapeRRC_0</source_block_id><sink_block_id>bpsk_bpskIQMap_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bpsk_bpskSoftDecision_0</source_block_id><sink_block_id>ccsds_synchronizeCADUSoft_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_createCADU_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_decodeLDPC_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>ccsds_decodeLDPC_0</source_block_id><sink_block_id>tdd_ferMsgCount_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ccsds_encodeLDPC_0</source_block_id><sink_block_id>ccsds_createCADU_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_recoverCADUSoft_0</source_block_id><sink_block_id>ccsds_decodeLDPC_0</sink_block_id><source_key>cadu</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ccsds_synchronizeCADUSoft_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_synchronizeCADUSoft_0</source_block_id><sink_block_id>ccsds_recoverCADUSoft_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>bpsk_bpskSoftDecision_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_prbs_source_b_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tdd_ferMsgCount_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>tdd_ferMsgCount_0</source_block_id><sink_block_id>tdd_nullMsgSink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>tdd_ferMsgGen_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
